# Keil uVision project explorer_readonly.uvprojx, settings and files
target explorer_ZG_loopback_READONLY (6070000::V6.7::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") ELITTLE
  output: explorer_ZG_loopback_READONLY
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=3 wLevel=3
  c define: STM32F407xx,USE_HAL_DRIVER,__MICROLIB,FLASH_TOTAL_SIZE=1048576u,HSE_VALUE=8000000u,OTA_EXPLORER_REFERENCE_PINS=1,OTA_EXPLORER_CAN_LOOPBACK=1,OTA_DIAG_UART=0,OTA_ENABLE_FLASHING=0,OTA_ENABLE_BOOT_HANDOFF=0,OTA_ENABLE_WATCHDOG=0
  c misc: -std=c99 -Wall -Wextra -mfloat-abi=soft
  c include: ..\platform\stm32f407\board\explorer_reference;..\include;..\platform\stm32f407\include;..\platform\stm32f407\examples;..\third_party\ed25519;..\..\..\..\Keil\Keil5\ARM\PACK\Keil\STM32F4xx_DFP\2.16.0\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\Keil\Keil5\ARM\PACK\Keil\STM32F4xx_DFP\2.16.0\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\Keil\Keil5\ARM\PACK\ARM\CMSIS\5.0.1\CMSIS\Include
  asm define: __MICROLIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\firmware\linker\bootloader_ZG.sct
  link misc: --entry Reset_Handler --strict
  group Portable core
    ../src/core/: boot.c can_uart.c crc32.c image.c isotp.c metadata.c signature.c uds.c watchdog_policy.c
  group STM32 adapters
    ../platform/stm32f407/src/: stm32_arch.c stm32_can.c stm32_diag.c stm32_eeprom.c stm32_handoff.c stm32_internal_flash.c stm32_ports.c stm32_spi_flash.c stm32_uart.c
  group Ed25519 (vendored)
    ../third_party/ed25519/: fe.c ge.c keypair.c sc.c sha512.c sign.c verify.c
  group Read-only Explorer BSP
    ../platform/stm32f407/board/explorer_reference/: explorer_reference.c explorer_interrupts.c
    ../platform/stm32f407/examples/: board_hal_binding.c
  group SPI NOR chip driver
    ../src/driver/: spi_nor.c
  group Firmware entry
    ../firmware/explorer_loopback/: main.c
  group Installed ST HAL and SystemInit
    ../../../../Keil/Keil5/ARM/PACK/Keil/STM32F4xx_DFP/2.16.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
    ../../../../Keil/Keil5/ARM/PACK/Keil/STM32F4xx_DFP/2.16.0/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group ST startup
    ../third_party/st/: startup_stm32f407xx.s
target explorer_ZG_uart_READONLY (6070000::V6.7::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: as above
  output: explorer_ZG_uart_READONLY
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=3 wLevel=3
  c define: STM32F407xx,USE_HAL_DRIVER,__MICROLIB,FLASH_TOTAL_SIZE=1048576u,HSE_VALUE=8000000u,OTA_EXPLORER_REFERENCE_PINS=1,OTA_EXPLORER_CAN_LOOPBACK=0,OTA_DIAG_UART=1,OTA_ENABLE_FLASHING=0,OTA_ENABLE_BOOT_HANDOFF=0,OTA_ENABLE_WATCHDOG=0
  c misc: -std=c99 -Wall -Wextra -mfloat-abi=soft
  c include: as above
  asm define: __MICROLIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\firmware\linker\bootloader_ZG.sct
  link misc: --entry Reset_Handler --strict
  group added to the first target's files
    ../firmware/bootloader/: main.c
  group left out of the first target's files
    ../firmware/explorer_loopback/: main.c
target explorer_ZE_loopback_READONLY (6070000::V6.7::ARMCLANG)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: as above
  output: explorer_ZE_loopback_READONLY
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=3 wLevel=3
  c define: STM32F407xx,USE_HAL_DRIVER,__MICROLIB,FLASH_TOTAL_SIZE=524288u,HSE_VALUE=8000000u,OTA_EXPLORER_REFERENCE_PINS=1,OTA_EXPLORER_CAN_LOOPBACK=1,OTA_DIAG_UART=0,OTA_ENABLE_FLASHING=0,OTA_ENABLE_BOOT_HANDOFF=0,OTA_ENABLE_WATCHDOG=0
  c misc: -std=c99 -Wall -Wextra -mfloat-abi=soft
  c include: as above
  asm define: __MICROLIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\firmware\linker\bootloader_ZE.sct
  link misc: --entry Reset_Handler --strict
target explorer_ZE_uart_READONLY (6070000::V6.7::ARMCLANG)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: as above
  output: explorer_ZE_uart_READONLY
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=3 wLevel=3
  c define: STM32F407xx,USE_HAL_DRIVER,__MICROLIB,FLASH_TOTAL_SIZE=524288u,HSE_VALUE=8000000u,OTA_EXPLORER_REFERENCE_PINS=1,OTA_EXPLORER_CAN_LOOPBACK=0,OTA_DIAG_UART=1,OTA_ENABLE_FLASHING=0,OTA_ENABLE_BOOT_HANDOFF=0,OTA_ENABLE_WATCHDOG=0
  c misc: -std=c99 -Wall -Wextra -mfloat-abi=soft
  c include: as above
  asm define: __MICROLIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\firmware\linker\bootloader_ZE.sct
  link misc: --entry Reset_Handler --strict
  group added to the first target's files
    ../firmware/bootloader/: main.c
  group left out of the first target's files
    ../firmware/explorer_loopback/: main.c
